<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>such_samples</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>"Such Samples, %s Wow!"%(filename)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>d</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_pyqt_text_input</key>
<param><key>id</key><value>f2</value></param>
<param><key>value</key><value>lambda x: numpy.correlate(numpy.abs(x), numpy.abs(x), 'same')</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>XMIT</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/psk_ldpc_xmit.dat</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0</value></param>
<param><key>l</key><value>Many Power</value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>l</key><value>Very Frequency</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>l</key><value>Much Time</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value>Very Correlate</value></param>
</block>
<block>
<key>pyqt_file_message_souce</key>
<param><key>id</key><value>pyqt_file_message_souce_0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>filename</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0</value></param>
<param><key>fn</key><value>f2</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0_0</value></param>
<param><key>fn</key><value>lambda x: numpy.log(1e-3+numpy.abs(x[0::d]))</value></param>
</block>
<block>
<key>pyqt_range_input</key>
<param><key>id</key><value>pyqt_range_input_0</value></param>
</block>
<block>
<key>pyqt_table</key>
<param><key>id</key><value>pyqt_table_0</value></param>
<param><key>columns</key><value>None</value></param>
<param><key>row_id</key><value>"filename"</value></param>
</block>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>file_range</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_range_input_0</sink_block_id><source_key>file_range</source_key><sink_key>file_range</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_cpower_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_cpsd_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_pdu_lambda_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_table_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_pdu_lambda_0</source_block_id><sink_block_id>pyqt_ctime_plot_0_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_range_input_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>range</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pyqt_range_input_0</source_block_id><sink_block_id>pyqt_file_message_souce_0</sink_block_id><source_key>range</source_key><sink_key>range</sink_key></connection>
</flow_graph>
